# Keil uVision project Card Test.uvproj, settings and files
target Card Test (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Card Test +hex
  c flags: Optim=1
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Project;.\FreeRTOS\include;.\FreeRTOS\Portable\Keil
  memory RVCT4: ROM 0x8000000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StdPeriphDrivers
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_dma.c
  group User Code
    ./Project/: main.c stm32f10x_it.c demo.c font5x7.c gdi.c mth.c sys.c video.c HardwareConfig.c
