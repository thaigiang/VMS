# Keil uVision project Led Controller.uvproj, settings and files
target LED Controller (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Led Controller +hex
  c flags: Optim=1
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Project;.\FreeRTOS\include;.\FreeRTOS\Portable\Keil
  memory RVCT4: ROM 0x8000000 size 0x76000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup code
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StdPeriphDrivers
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_iwdg.c
  group User Code
    ./Project/: main.c stm32f10x_it.c ledMatrix.c HardwareConfig.c font.c c_func.c
